# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8052 (all Variants) Generic
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: Demo +hex
  c flags: Optimize=9
  c misc: interval(3)
  c include: ..\..\Libraries\Include;..\..\User
  asm include: ..\..\Libraries;..\..\Libraries\C51
  group Startup
    ../../Libraries/Startup/: STARTUP.A51
    ../../Libraries/Source/: system.c
  group User
    ../../User/: main.c pwm.c adc.c time0.c my_config.h timer2.c knob_dimming.c rf_recv.c key_driver.c flash.c fan_ctl.c timer3.c engine.c
    ../../Libraries/Source/: debug.c
